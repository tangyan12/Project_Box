# Keil uVision project My_Examples.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: My_Examples
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars --diag_suppress=167,513
  c include: .\Hardware;.\System;.\User;.\Config;.\CORE;.\Library\inc;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM3;.\Hardware\24CXX;.\Hardware\AS608;.\Hardware\ESP8266;.\Hardware\IIC;.\Hardware\LCD;.\Hardware\RC522;.\Hardware\SG90;.\System\delay;.\System\uart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group FreeRTOS_CORE
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
    ./FreeRTOS/portable/MemMang/: heap_4.c
  group FreeRTOS_inc
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_hd.s
  group SYSTEM
    ./System/delay/: MyDelay.c
    ./System/uart/: MyUART3.c
  group BSP
    ./Hardware/24CXX/: 24cxx.c
    ./Hardware/AS608/: AS608.c
    ./Hardware/ESP8266/: ESP8266.c
    ./Hardware/IIC/: myiic.c
    ./Hardware/LCD/: lcd.c
    ./Hardware/RC522/: rc522.c
    ./Hardware/SG90/: SG90.c
    ./Hardware/: touch.c
  group Config
    ./Config/: FreeRTOSConfig.h stm32f10x_conf.h
  group User
    ./User/: main.c stm32f10x_it.c system_stm32f10x.c
